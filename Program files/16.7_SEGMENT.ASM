CSEG AT 0100H
	LUT: DB 0XC0,0XF9,0XA4,0XB0,0X99,0X92,0X82,0XF8,0X80,0X90
CSEG AT 0
	START:
	MOV DPTR, #LUT
	REP:
	CLR A
	MOVC A, @A + DPTR
	MOV P2 , A
	MOV A,DPL    ; A INITIALISATION FOR CJNE COMPARISON
	INC DPTR
	ACALL DELAY
	CJNE A, #09, REP ; COUNT TILL 9 THEN EXIT LOOP
	SJMP START ; INFINITE LOOP OF 0-9 DISPLAY
	
	DELAY:       ; 1 SEC DELAY
	MOV R0, #8
	L3:
	MOV R1, #240
	L2:
	MOV R2, #240
	L1:	
	DJNZ R2, L1	
	DJNZ R1, L2
	DJNZ R0, L3
	RET
END