CSEG AT 0400H
STRING: DB "THE EARTH IS BUT ONE COUNTRY " 
CSEG AT 0
	SW EQU P1.7
	MOV TMOD, #20H
	MOV TH1, #-3	;DEFAULT BAUD RATE: 9600
	MOV SCON, #50H
	SETB TR1
	
	MOV DPTR, #STRING
	REP:
	CLR A
	MOVC A,@A+ DPTR
	MOV SBUF,A
	WAIT: JNB TI, WAIT
	CLR TI
	INC DPTR
	JNB SW, RES1
	JB SW, RES2
	SJMP REP
	
	
	RES1: 
	MOV A, PCON
	SETB ACC.7
	MOV PCON,A
	CLR A
	SJMP REP
	RES2:
	MOV A, PCON
	CLR ACC.7
	MOV PCON,A
	CLR A
	SJMP REP

END	