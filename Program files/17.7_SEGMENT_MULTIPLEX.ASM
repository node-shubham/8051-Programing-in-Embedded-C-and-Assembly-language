CSEG AT 0100H ; COUNTING FROM 0-99
	LUT: DB 0XC0,0XF9,0XA4,0XB0,0X99,0X92,0X82,0XF8,0X80,0X90
CSEG AT 0
	MOV DPTR, #0100
	AGAIN:
	CLR A
	CLR P3.0
	MOVC A, @A +DPTR
	MOV P2, A
	CLR P3.0
	ACALL DELAY_300MS
	SETB P3.0
	
	MOV DPTR, #0100
	REP:
	CLR A
	CLR P3.1
	MOVC A, @A +DPTR
	MOV P2, A 
	MOV A, DPL
	ACALL DELAY_300MS
	SETB P3.1
	INC DPTR
	CJNE A,#9, REP
	SJMP AGAIN
	
	MOV R0, #6
	DELAY_50MS: 		; HUMAN EYE REFRESH RATE : 100ms
	L3:
	MOV R1, #240
	L2: 
	MOV R2, #200
	L1:	
	DJNZ R2, L1	; L1: 400us
	DJNZ R1, L2	; 240*200 ~= 50000us = 50ms
	RET
	
	DELAY_300MS:
	;ACALL DELAY_50MS
	DJNZ R0, DELAY_50MS
	RET
END