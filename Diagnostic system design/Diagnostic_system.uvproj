# Keil uVision project Diagnostic_system.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: project1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: glcd.c mcp3204.c uart.c delay.h glcd.h i2c.h i2c_defines.h lcd1.h mcp3204.h mcp3204_defines.h spi.h spi_defines.h types.h uart.h i2c.c main_project.c lcd.c delay.c main_glcd.c
